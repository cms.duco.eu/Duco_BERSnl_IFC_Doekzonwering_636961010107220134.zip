Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T16:02:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 16:02:09 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{B6ECC83A-8391-41FC-B2D3-A0CD29DF29BB}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 16:02:08 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 16:02:08 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 16:02:08 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcBuildingElementProxy: fix - buis 75_duco_ducoscreen front 150, BERSnl_31_GM_FB_zonwering - ducoscreen front 150_duco:fix - buis 75_duco_ducoscreen front 150:208862
In: Level 1
Type - Classification: 31.2 (Uniformat); Material: BERSnl_h4_aluminium, Linen, White
Type - Constraints(Type) - Default Elevation: 1500 mm; WT_H Geleider_type: BERSnl_31_GM_FB_geleider - SH_duco: fix_duco_ducoscreen front 150; ZZZ_Afstand tussen zonwering_Exterior_Length: 0 mm; ZZZ_cutout bottom_height_Length: 0 mm; ZZZ_cutouts_height_Length: 150 mm; ZZZ_cutouts_height2_Length: 150 mm; ZZZ_cutout top_height_Length: 0 mm; ZZZ_end caps_length_Length: 2 mm; ZZZ_installation on window_YesNo: yes; ZZZ_length arrow_Length: 310 mm; ZZZ_side conductor_depth_Length: 110 mm; ZZZ_side conductor_width_Length: 36 mm; ZZZ_sunscreen_YesNo: yes; ZZZ_Terminal exterior_depth_Length: 110 mm
Type - Dimensions(Type) - BERSnl_C_diepte: 110 mm; BERSnl_C_hoogte: 150 mm
Type - Identity Data(Type) - Assembly Code: 31.2; BERSnl_C_code_artikel: DucoScreen Front 150_fix; BERSnl_C_code_ETIM: Rolluik; BERSnl_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC003229&classVersion=1; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 22/04/2016; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: V2; BERSnl_C_description: duco_ducoscreen front 150_fix; BERSnl_C_model: DucoScreen Front 150; BERSnl_C_revit_versie: 2016; BERSnl_C_type: fix; BERSnl_C_type_comments: zonwering; Description: duco_ducoscreen front 150_fix; Manufacturer: Duco; Model: DucoScreen Front 150; OmniClass Number: 3A(57.16.11); Type Comments: zonwering; Type Name: fix - buis 75_duco_ducoscreen front 150; URL: http://www.duco.eu/producten/; WT_I BaseKeynote: 31.2
Type - Materials and Finishes(Type) - BERSnl_C_materiaal: BERSnl_h4_aluminium; WT_V Eindplaat_materiaal: BERSnl_h4_aluminium; WT_V Zonwering_materiaal: Linen, White
Type - Model Properties(Type) - WT_I Buis 63: no; WT_I Buis 75: yes; WT_I Buis 78: no; WT_I Kleur: -; WT_I Maximale breedte: 6000 mm; WT_I Maximale hoogte: 3600 mm; WT_I Minimale breedte: 800 mm; WT_I Zonwering_gemotoriseerd: yes; WT_I Zonwering_manueel: no; WT_I Zonwering_oppervlakte: 21.6 m2
Type - Other(Type) - Category: Generic Models; Family Name: BERSnl_31_GM_FB_zonwering - ducoscreen front 150_duco
Pset_BuildingElementProxyCommon - Reference: fix - buis 75_duco_ducoscreen front 150
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; ZZZ_cutouts_length_Length: 1200 mm; ZZZ_side conductor_height_Length: 1200 mm; ZZZ_Terminal interior_depth_Length: 0 mm; ZZZ_Terminal interior_length_Length: 1196 mm
Construction - WT_V Afrollen aan buitenzijde: yes; WT_V Afrollen aan raamzijde: no; WT_V Eindplaat_hellende geleider: yes; WT_V Vlakke geleider_eindkap: no; WT_V Zijgeleider_height: 1200 mm; WT_V Zonwering_bediening: BERSnl_31_GM_FB_bediening zonwering - SH_duco: buismotor met afstandsbediening_duco_bediening zonweringdoek; WT_V Zonwering_opening lengte: 500 mm
Dimensions - Area: 1.42301 m2; BERSnl_C_lengte: 1200 mm; Volume: 0.0321211 m3; WT_V Lengte: 1200 mm
Other - Category: Generic Models; Family: BERSnl_31_GM_FB_zonwering - ducoscreen front 150_duco: fix - buis 75_duco_ducoscreen front 150; Family and Type: BERSnl_31_GM_FB_zonwering - ducoscreen front 150_duco: fix - buis 75_duco_ducoscreen front 150; Schedule Level: Level: Level 1; Type: BERSnl_31_GM_FB_zonwering - ducoscreen front 150_duco: fix - buis 75_duco_ducoscreen front 150; Type Id: BERSnl_31_GM_FB_zonwering - ducoscreen front 150_duco: fix - buis 75_duco_ducoscreen front 150
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/duco

# IfcBuildingElementProxy: fix_duco_ducoscreen front 150 (2)
In: Level 1
Type - Classification: 31.2 (Uniformat); Material: BERSnl_h4_aluminium
Type - Constraints(Type) - Default Elevation: 1219.2 mm
Type - Construction(Type) - WT_V Fix: yes; WT_V Standaard: no
Type - Dimensions(Type) - WT_V Breedte: 36 mm; WT_V Diepte: 110 mm
Type - Identity Data(Type) - Assembly Code: 31.2; BERSnl_C_code_ETIM: Rolluik; BERSnl_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC003229&classVersion=1; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 22/04/2016; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: V2; BERSnl_C_description: geleider_fix_duco_ducoscreen front 150; BERSnl_C_model: DucoScreen Front 150; BERSnl_C_revit_versie: 2016; BERSnl_C_type: standaard; BERSnl_C_type_comments: geleider; Description: geleider_fix_duco_ducoscreen front 150; Manufacturer: Duco; Model: DucoScreen Front 150; Type Comments: geleider; Type Name: fix_duco_ducoscreen front 150; URL: http://www.duco.eu/producten/; WT_I BaseKeynote: 31.2
Type - Other(Type) - Category: Generic Models; Family Name: BERSnl_31_GM_FB_geleider - SH_duco
Pset_BuildingElementProxyCommon - Reference: fix_duco_ducoscreen front 150
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Constraints - Moves With Nearby Elements: no
Construction - WT_V Afrollen aan buitenzijde: yes; WT_V Afrollen aan raamzijde: no
Dimensions - BERSnl_C_lengte: 1200 mm; Volume: 0.000943131 m3
Materials and Finishes - BERSnl_C_materiaal: BERSnl_h4_aluminium
Other - Category: Generic Models; Family: BERSnl_31_GM_FB_geleider - SH_duco: fix_duco_ducoscreen front 150; Family and Type: BERSnl_31_GM_FB_geleider - SH_duco: fix_duco_ducoscreen front 150; Type: BERSnl_31_GM_FB_geleider - SH_duco: fix_duco_ducoscreen front 150; Type Id: BERSnl_31_GM_FB_geleider - SH_duco: fix_duco_ducoscreen front 150
Phasing - Phase Created: New Construction
Name (BERSnl_31_GM_FB_geleider - SH_duco:fix_duco_ducoscreen front 150:...)
208864
208865
